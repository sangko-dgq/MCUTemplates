# Keil uVision project iWatch-v2.0.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: iWatch-v2.0 +hex
  group og_core
    ./User/oled_gui/oled_core/: oled_anim.c oled_draw.c oled_font.c oled_group.c oled_gui.c oled_widget.c
    ./User/oled_gui/: oled_conf.h GT20L16S1Y.c
  group og_widget
    ./User/oled_gui/oled_widget/: oled_bmp.c oled_slider.c oled_switch.c oled_canvas.c oled_label.c
  group System
    ./User/System/: Buzzer.c Delay.c EEPROM.C IIC.c SPI.c System.c
    ./User/: RX8130CE.c oled.c
  group iWatch
    ./User/: main.c iWatch.c iWatch.h
  group Sensor
    ./User/Sensor/: LSM6DSM.c QMC5883L.c Ellipsoid fitting.c BMP390.c HDC2080.c HTU21D.c
  group Page
    ./User/PageManage/: pageManager.c page_alarm.c page_compass.c page_devInfo.c page_flashlight.c page_hdc2080.c page_ilink.c page_lsm6dsl.c page_magcal.c page_menu.c page_pedometer.c page_settime.c page_setting.c page_snake.c page_trexrunner.c page_watch.c page_btspp.c page_stopwatch.c
  group Bluetooth
    ./User/Bluetooth/: Bluetooth.c
