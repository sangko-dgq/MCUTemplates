# Keil uVision project OLED_高刷新率图片显示.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: OLED_高刷新率图片显示 +hex
  group Source Group 1
    ./: main.c oled.c oled.h oledfont.h
