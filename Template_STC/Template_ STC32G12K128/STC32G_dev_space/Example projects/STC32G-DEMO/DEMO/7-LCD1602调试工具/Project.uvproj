# Keil uVision project Project.uvproj, settings and files
target LED (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: Project +hex
  group Source
    ./: LCD1602.c LCD1602.h Project.c
