# Keil uVision project Temp_F411CEUX_CPP.uvprojx, settings and files
target Temp_F411CEUX_CPP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp_F411CEUX_CPP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1 --diag_suppress=223
  c include: ..\Core\core_cm;..\Core\core_basic_driver;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Libs\ArduinoAPI;..\Libs\Quick_STD;..\..\Temp_F411CEUX_CPP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core/startup
    ../Core/startup/: startup_stm32f411xe.s
  group Core/stdlib
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Core/basic_driver
    ../Core/core_basic_driver/: stm32f4xx_it.c system_stm32f4xx.c
  group Libs/ArduinoAPI
    ../Libs/ArduinoAPI/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp SPI.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Libs/Quick_STD
    ../Libs/Quick_STD/: adc.c delay.c exti.c flash.c gpio.c pwm.c rtc.c timer.c
  group User
    ../User/: main.cpp APP_Config.h HAL_Config.h
  group User/HAL
    ../User/HAL/: HAL.cpp HAL_led_test.cpp
