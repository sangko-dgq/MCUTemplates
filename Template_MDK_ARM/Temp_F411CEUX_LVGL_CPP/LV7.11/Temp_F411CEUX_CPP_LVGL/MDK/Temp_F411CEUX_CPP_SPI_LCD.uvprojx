# Keil uVision project Temp_F411CEUX_CPP_SPI_LCD.uvprojx, settings and files
target Temp_F411CEUX_CPP_SPI_LCD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Temp_F411CEUX_CPP_SPI_LCD +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,ARDUINO=111
  c misc: --diag_suppress=1 --diag_suppress=223 --diag_suppress=174  --gnu  --diag_suppress=111 --diag_suppress=167
  c include: ..\..\Temp_F411CEUX_CPP_LVGL;..\Core\core_cm;..\Core\core_basic_driver;..\Core\STM32F4xx_StdPeriph_Driver\inc;..\Libs;..\Libs\ArduinoAPI;..\Libs\Quick_STD;..\Libs\Adafruit_ST7789;..\Libs\Adafruit_GFX_Library;..\Libs\LittleVGL;..\Libs\LittleVGL\lvgl;..\User\APP\LV_Porting;..\User\APP\APP_LVGL\IMG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Core/startup
    ../Core/startup/: startup_stm32f411xe.s
  group Core/stdlib
    ../Core/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Core/basic_driver
    ../Core/core_basic_driver/: stm32f4xx_it.c system_stm32f4xx.c
  group Libs/ArduinoAPI
    ../Libs/ArduinoAPI/: Arduino.c itoa.c HardwareSerial.cpp SPI.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp Print.cpp
    ../Libs/ArduinoAPI/avr/: dtostrf.c
  group Libs/Quick_STD
    ../Libs/Quick_STD/: adc.c delay.c exti.c flash.c gpio.c pwm.c rtc.c timer.c
  group Libs/LittleVGL7
    ../Libs/LittleVGL/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../Libs/LittleVGL/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Libs/LittleVGL/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Libs/LittleVGL/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Libs/LittleVGL/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Libs/LittleVGL/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../Libs/LittleVGL/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group Libs/Display
    ../Libs/Adafruit_ST7789/: Adafruit_ST7789.cpp
    ../Libs/Adafruit_GFX_Library/: Adafruit_GFX.cpp
  group Libs/SystemTask
    ../Libs/MillisTaskManager/: MillisTaskManager.cpp
  group Libs/Button
    ../Libs/ButtonEvent/: ButtonEvent.cpp
  group Libs/CommonMacro
    ../Libs/CommonMacro/: CommonMacro.h
  group Libs/LVGL7_ExMeathods
    ../Libs/LVGL_ExMethods/: lv_anim_timeline.cpp lv_label_anim_effect.cpp lv_obj_ext_func.cpp lv_theme_watchx.c
  group User
    ../User/: main.cpp APP_Config.h HAL_Config.h
  group User/HAL
    ../User/HAL/: HAL.cpp HAL_led_test.cpp HAL_TFTLcd_TEST.cpp HAL_Button.cpp HAL_Power.cpp HAL_Backlight.cpp
  group User/MID
    ../User/MID/: MID_Button.cpp MID.h MID_UsartOrder.cpp
  group User/APP
    ../User/APP/: APP.cpp
  group User/APP/LV_Porting
    ../User/APP/LV_Porting/: lv_port_disp.cpp
    ../Libs/LittleVGL/: lv_conf.h
  group Page
    ../User/APP/LV_APP/Test/: Input_num_test.cpp
    ../User/APP/LV_APP/Page/: LvQuick.cpp Test002.cpp
  group Resources
    ../User/APP/LV_APP/Resources/: ResourceManager.cpp
  group Resources/IMGS
    ../User/APP/LV_APP/Page/images/: about_64.c conversation_64.c ios_music_64.c ios_recorder_64.c map_64.c setting_64.c sports_64.c tv_64.c
  group Resources/FONT
    ../User/APP/LV_APP/Page/fonts/: LiquidCrystal_ExBold_16.c LiquidCrystal_ExBold_32.c LiquidCrystal_ExBold_48.c LiquidCrystal_ExBold_64.c Sarasa_Mono_SC_light_16.c Sarasa_Mono_SC_regular_12.c Sarasa_Mono_SC_regular_16.c UbuntuMono_Bold_12.c
  group Resources/Symbols
    ../User/APP/LV_APP/Page/Symbols/: FontAwesome4.c FontAwesome5.c IconFontSymbols.c
